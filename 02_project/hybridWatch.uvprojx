# Keil uVision project hybridWatch.uvprojx, settings and files
target hybridWatch (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: hybridWatch +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD FREERTOS NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=6 S132 SOFTDEVICE_PRESENT __HEAP_SIZE=1024 __STACK_SIZE=2048
  c misc: --reduce_paths
  c include: ..\00_include\config;..\components;..\components\nfc\t2t_lib;..\components\nfc\t4t_parser\hl_detection_procedure;..\components\ble\ble_services\ble_ancs_c;..\components\ble\ble_services\ble_ias_c;..\components\libraries\pwm;..\components\softdevice\s132\headers\nrf52;..\components\libraries\usbd\class\cdc\acm;..\components\libraries\usbd\class\hid\generic;..\components\libraries\usbd\class\msc;..\components\libraries\usbd\class\hid;..\modules\nrfx\hal;..\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\components\libraries\log;..\components\ble\ble_services\ble_gls;..\components\libraries\fstorage;..\components\nfc\ndef\text;..\components\libraries\mutex;..\components\libraries\gpiote;..\components\libraries\bootloader\ble_dfu;..\components\nfc\ndef\connection_handover\common;..\components\boards;..\components\nfc\ndef\generic\record;..\components\nfc\t4t_parser\cc_file;..\components\ble\ble_advertising;..\external\utf_converter;..\components\ble\ble_services\ble_bas_c;..\modules\nrfx\drivers\include;..\components\libraries\experimental_task_manager;..\components\ble\ble_services\ble_hrs_c;..\components\nfc\ndef\connection_handover\le_oob_rec;..\components\libraries\queue;..\components\libraries\pwr_mgmt;..\external\freertos\portable\GCC\nrf52;..\components\ble\ble_dtm;..\components\toolchain\cmsis\include;..\components\ble\ble_services\ble_rscs_c;..\components\ble\common;..\components\ble\ble_services\ble_lls;..\components\libraries\hardfault\nrf52;..\components\libraries\bsp;..\components\nfc\ndef\connection_handover\ac_rec;..\components\ble\ble_services\ble_bas;..\components\libraries\mpu;..\components\libraries\experimental_section_vars;..\components\softdevice\s132\headers;..\components\ble\ble_services\ble_ans_c;..\components\libraries\slip;..\components\libraries\delay;..\components\libraries\mem_manager;..\components\libraries\csense_drv;..\components\libraries\memobj;..\components\ble\ble_services\ble_nus_c;..\components\softdevice\common;..\components\ble\ble_services\ble_ias;..\components\libraries\usbd\class\hid\mouse;..\components\libraries\low_power_pwm;..\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\components\ble\ble_services\ble_dfu;..\external\fprintf;..\components\libraries\svc;..\components\libraries\atomic;..\components;..\components\libraries\scheduler;..\components\libraries\cli;..\components\ble\ble_services\ble_lbs;..\components\ble\ble_services\ble_hts;..\components\libraries\crc16;..\components\nfc\t4t_parser\apdu;..\external\freertos\config;..\components\libraries\util;..\external\freertos\portable\CMSIS\nrf52;..\components\libraries\usbd\class\cdc;..\components\libraries\csense;..\components\libraries\balloc;..\components\libraries\ecc;..\components\libraries\hardfault;..\components\ble\ble_services\ble_cscs;..\components\libraries\hci;..\components\libraries\usbd\class\hid\kbd;..\components\libraries\timer;..\integration\nrfx;..\components\nfc\t4t_parser\tlv;..\components\libraries\sortlist;..\components\libraries\spi_mngr;..\components\libraries\led_softblink;..\components\nfc\ndef\conn_hand_parser;..\components\libraries\sdcard;..\components\nfc\ndef\parser\record;..\modules\nrfx\mdk;..\components\ble\ble_services\ble_cts_c;..\components\ble\ble_services\ble_nus;..\components\libraries\twi_mngr;..\components\ble\ble_services\ble_hids;..\components\libraries\strerror;..\components\libraries\crc32;..\components\nfc\ndef\connection_handover\ble_oob_advdata;..\components\nfc\t2t_parser;..\external\freertos\source\include;..\components\nfc\ndef\connection_handover\ble_pair_msg;..\components\libraries\usbd\class\audio;..\components\nfc\t4t_lib\hal_t4t;..\components\libraries\sensorsim;..\components\nfc\t4t_lib;..\components\ble\peer_manager;..\components\drivers_nrf\usbd;..\components\libraries\ringbuf;..\components\ble\ble_services\ble_tps;..\components\nfc\ndef\parser\message;..\components\ble\ble_services\ble_dis;..\components\nfc\ndef\uri;..\components\ble\nrf_ble_gatt;..\components\ble\nrf_ble_qwr;..\components\libraries\gfx;..\components\libraries\button;..\modules\nrfx;..\components\libraries\twi_sensor;..\integration\nrfx\legacy;..\components\libraries\usbd;..\components\nfc\ndef\connection_handover\ep_oob_rec;..\external\segger_rtt;..\components\libraries\atomic_fifo;..\components\ble\ble_services\ble_lbs_c;..\components\nfc\ndef\connection_handover\ble_pair_lib;..\components\libraries\crypto;..\components\ble\ble_racp;..\components\libraries\fds;..\components\nfc\ndef\launchapp;..\components\libraries\atomic_flags;..\components\ble\ble_services\ble_hrs;..\components\ble\ble_services\ble_rscs;..\components\nfc\ndef\connection_handover\hs_rec;..\components\nfc\t2t_lib\hal_t2t;..\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\components\libraries\stack_guard;..\components\libraries\log\src
  asm define: as above
  asm misc: --cpreproc_opts=-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DFREERTOS,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DNRF_SD_BLE_API_VERSION=6,-DS132,-DSOFTDEVICE_PRESENT,-D__HEAP_SIZE=1024,-D__STACK_SIZE=2048
  asm include: ..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\components\ble\ble_racp;..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\..\..\..\components\ble\ble_services\ble_cscs;..\..\..\..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\components\ble\ble_services\ble_gls;..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\components\ble\ble_services\ble_hts;..\..\..\..\..\..\components\ble\ble_services\ble_ias;..\..\..\..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\..\..\..\components\ble\ble_services\ble_lbs;..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\..\components\ble\ble_services\ble_lls;..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\..\..\..\components\ble\ble_services\ble_rscs;..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\..\components\ble\ble_services\ble_tps;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\nrf_ble_gatt;..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\usbd;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\components\libraries\atomic_flags;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bootloader\ble_dfu;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\cli;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\components\libraries\crypto;..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\components\libraries\ecc;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\experimental_task_manager;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\gfx;..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\components\libraries\hardfault\nrf52;..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\components\libraries\mpu;..\..\..\..\..\..\components\libraries\mutex;..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\components\libraries\pwr_mgmt;..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\sdcard;..\..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\components\libraries\sortlist;..\..\..\..\..\..\components\libraries\spi_mngr;..\..\..\..\..\..\components\libraries\stack_guard;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\svc;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\twi_mngr;..\..\..\..\..\..\components\libraries\twi_sensor;..\..\..\..\..\..\components\libraries\usbd;..\..\..\..\..\..\components\libraries\usbd\class\audio;..\..\..\..\..\..\components\libraries\usbd\class\cdc;..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\..\components\libraries\usbd\class\hid;..\..\..\..\..\..\components\libraries\usbd\class\hid\generic;..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd;..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse;..\..\..\..\..\..\components\libraries\usbd\class\msc;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser;..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ac_rec;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_oob_advdata;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_lib;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_msg;..\..\..\..\..\..\components\nfc\ndef\connection_handover\common;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ep_oob_rec;..\..\..\..\..\..\components\nfc\ndef\connection_handover\hs_rec;..\..\..\..\..\..\components\nfc\ndef\connection_handover\le_oob_rec;..\..\..\..\..\..\components\nfc\ndef\generic\message;..\..\..\..\..\..\components\nfc\ndef\generic\record;..\..\..\..\..\..\components\nfc\ndef\launchapp;..\..\..\..\..\..\components\nfc\ndef\parser\message;..\..\..\..\..\..\components\nfc\ndef\parser\record;..\..\..\..\..\..\components\nfc\ndef\text;..\..\..\..\..\..\components\nfc\ndef\uri;..\..\..\..\..\..\components\nfc\t2t_lib;..\..\..\..\..\..\components\nfc\t2t_lib\hal_t2t;..\..\..\..\..\..\components\nfc\t2t_parser;..\..\..\..\..\..\components\nfc\t4t_lib;..\..\..\..\..\..\components\nfc\t4t_lib\hal_t4t;..\..\..\..\..\..\components\nfc\t4t_parser\apdu;..\..\..\..\..\..\components\nfc\t4t_parser\cc_file;..\..\..\..\..\..\components\nfc\t4t_parser\hl_detection_procedure;..\..\..\..\..\..\components\nfc\t4t_parser\tlv;..\..\..\..\..\..\components\softdevice\common;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\external\freertos\config;..\..\..\..\..\..\external\freertos\portable\ARM\nrf52;..\..\..\..\..\..\external\freertos\portable\CMSIS\nrf52;..\..\..\..\..\..\external\freertos\source\include;..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\external\utf_converter;..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\..\modules\nrfx\mdk;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5a000
  memory RVCT9: RAM 0x200057b8 size 0xa848
  link misc: --diag_suppress 6330
  group Application
    ../01_source/: main.c
    ../00_include/config/: FreeRTOSConfig.h sdk_config.h
  group Board Definition
    ../components/boards/: boards.c
  group Board Support
    ../components/libraries/bsp/: bsp.c bsp_btn_ble.c
  group Third Parties
    ../external/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../external/freertos/source/portable/MemMang/: heap_4.c
    ../external/freertos/portable/ARM/nrf52/: port.c
    ../external/freertos/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c
  group UTF8/UTF16 converter
    ../external/utf_converter/: utf.c
  group nRF_BLE
    ../components/ble/peer_manager/: auth_status_tracker.c gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c peer_manager_handler.c pm_buffer.c security_dispatcher.c security_manager.c
    ../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../components/ble/ble_advertising/: ble_advertising.c
    ../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
  group nRF_BLE_Services
    ../components/ble/ble_services/ble_bas/: ble_bas.c
    ../components/ble/ble_services/ble_dis/: ble_dis.c
    ../components/ble/ble_services/ble_hrs/: ble_hrs.c
  group nRF_Drivers
    ../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_uart.c
    ../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_power_clock.c nrfx_uart.c nrfx_uarte.c
    ../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../components/libraries/button/: app_button.c
    ../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../components/libraries/timer/: app_timer_freertos.c
    ../components/libraries/crc16/: crc16.c
    ../components/libraries/fds/: fds.c
    ../components/libraries/hardfault/nrf52/handler/: hardfault_handler_keil.c
    ../components/libraries/hardfault/: hardfault_implementation.c
    ../components/libraries/atomic/: nrf_atomic.c
    ../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../components/libraries/atomic_flags/: nrf_atflags.c
    ../components/libraries/balloc/: nrf_balloc.c
    ../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../components/libraries/memobj/: nrf_memobj.c
    ../components/libraries/ringbuf/: nrf_ringbuf.c
    ../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../components/libraries/strerror/: nrf_strerror.c
    ../components/libraries/sensorsim/: sensorsim.c
  group nRF_Log
    ../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_freertos.c nrf_sdh_soc.c
target flash_s132_nrf52_6.1.0_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: as above
  output: s132_nrf52_6.1.0_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: __HEAP_SIZE=1024 __STACK_SIZE=2048
  c misc: --reduce_paths
  c include: ..\..\..\config;..\config
  asm define: __HEAP_SIZE=1024 __STACK_SIZE=2048
  asm misc: --cpreproc_opts=-D__HEAP_SIZE=1024,-D__STACK_SIZE=2048
  asm include: ..\..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5a000
  memory RVCT9: RAM 0x200057b8 size 0xa848
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 4.3.0, Device:Startup 8.17.0
